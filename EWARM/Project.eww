<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Adafruit_Feather_STM32F405.ewp</path>
  </project>
  <batchBuild />
</workspace>
